# IAR project template.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa089,Pe188
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: lpc4088.hex
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
