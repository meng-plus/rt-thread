# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__; CORE_M4
  ICCARM.CCDiagSuppress: Pa089,Pe188
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: packages\LVGL-v8.3.5\src\extra\others; ..\..\components\dfs\dfs_v1\include; ..\..\include; packages\LVGL-v8.3.5\src\extra\widgets\meter; ..\..\libcpu\arm\common; packages\LVGL-v8.3.5\src\extra\widgets\span; packages\LVGL-v8.3.5\src\extra\layouts\grid; packages\LVGL-v8.3.5\src\draw; drivers\key_Ird; applications\system; ..\..\components\fal\inc; applications\lvgl; ..\..\components\drivers\ktime\inc; Libraries\Drivers\spifi; packages\LVGL-v8.3.5\src\widgets; packages\LVGL-v8.3.5\src\extra\themes\basic; ..\..\components\drivers\ktime; applications\lvgl\components; packages\LVGL-v8.3.5\src\draw\nxp\pxp; packages\LVGL-v8.3.5\src\extra\widgets\win; packages\LVGL-v8.3.5\src\extra\widgets\led; packages\LVGL-v8.3.5\src\extra\widgets\tabview; packages\LVGL-v8.3.5\src\hal; packages\LVGL-v8.3.5\src\extra\others\ime; packages\agile_modbus-v1.1.2\util; Libraries\Drivers\include; ..\..\components\libc\posix\io\epoll; packages\FlashDB-v1.1.2\inc; packages\LVGL-v8.3.5\src\draw\sw; packages\LVGL-v8.3.5\src\extra\widgets\tileview; packages\LVGL-v8.3.5\src\draw\arm2d; packages\LVGL-v8.3.5\src\extra\others\monkey; drivers\ADXL345\inc; packages\LVGL-v8.3.5\src\extra\others\msg; applications\Protocol; Libraries\CMSIS\Include; packages\LVGL-v8.3.5\src\core; Libraries\Device\NXP\LPC407x_8x_177x_8x\Include; packages\LVGL-v8.3.5\src\extra\libs\qrcode; ..\..\components\libc\posix\ipc; ..\..\components\dfs\dfs_v1\filesystems\devfs; packages\LVGL-v8.3.5\src\extra\widgets; packages\LVGL-v8.3.5\src\extra\libs\freetype; packages\LVGL-v8.3.5\src\extra\layouts\flex; packages\LVGL-v8.3.5\src; drivers\lvgl; packages\LVGL-v8.3.5\src\extra\libs\gif; ..\..\components\drivers\spi; ..\..\components\libc\compilers\common\extension\fcntl\octal; packages\LVGL-v8.3.5\src\draw\stm32_dma2d; applications\lvgl\screens; ..\..\components\finsh; packages\LVGL-v8.3.5\src\extra; packages\LVGL-v8.3.5\src\draw\swm341_dma2d; packages\LVGL-v8.3.5\src\extra\themes\mono; drivers\Fal\inc; applications\DOIC_protocol; packages\LVGL-v8.3.5\src\extra\others\fragment; packages\LVGL-v8.3.5\src\extra\libs\ffmpeg; packages\LVGL-v8.3.5\src\font; packages\LVGL-v8.3.5\env_support\rt-thread; packages\LVGL-v8.3.5\src\extra\widgets\spinbox; packages\LVGL-v8.3.5\src\extra\widgets\msgbox; packages\LVGL-v8.3.5\src\draw\nxp\vglite; packages\LVGL-v8.3.5\src\extra\widgets\menu; packages\LVGL-v8.3.5\src\extra\themes\default; packages\LVGL-v8.3.5\src\draw\sdl; packages\agile_modbus-v1.1.2\inc; ..\..\components\drivers\include; ..\..\components\dfs\dfs_v1\filesystems\tmpfs; packages\LVGL-v8.3.5\src\extra\others\gridnav; packages\LVGL-v8.3.5\src\extra\widgets\chart; ..\..\components\drivers\touch; packages\SEGGER_RTT-latest\RTT; .; ..\..\libcpu\arm\cortex-m4; packages\LVGL-v8.3.5\src\extra\libs\png; packages\LVGL-v8.3.5\src\extra\libs; packages\LVGL-v8.3.5\src\extra\widgets\keyboard; ..\..\components\libc\posix\io\eventfd; ..\..\components\libc\compilers\common\include; packages\LVGL-v8.3.5\src\extra\libs\fsdrv; packages\LVGL-v8.3.5\src\extra\widgets\animimg; ..\..\components\libc\posix\delay; packages\LVGL-v8.3.5\src\extra\others\snapshot; drivers\FM31XX\inc; packages\LVGL-v8.3.5\src\extra\libs\bmp; packages\LVGL-v8.3.5\src\misc; packages\LVGL-v8.3.5\src\extra\widgets\spinner; applications\SDC_protocol; packages\LVGL-v8.3.5\src\extra\themes; drivers\FlashDB; packages\LVGL-v8.3.5\src\extra\others\imgfont; drivers; applications\DTS; packages\LVGL-v8.3.5\src\extra\widgets\imgbtn; packages\LVGL-v8.3.5\src\extra\widgets\colorwheel; packages\LVGL-v8.3.5\src\extra\widgets\calendar; ..\..\components\utilities\ulog; packages\LVGL-v8.3.5\src\extra\libs\rlottie; applications; packages\LVGL-v8.3.5\src\extra\libs\sjpg; packages\LVGL-v8.3.5\src\extra\widgets\list; ..\..\components\libc\compilers\common\extension; drivers\ad7843\inc; ..\..\components\libc\posix\io\poll; packages\LVGL-v8.3.5\src\extra\layouts; packages\SEGGER_RTT-latest
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: lpc4088.hex
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__; CORE_M4
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group ad7843
    drivers/ad7843/src/: ad7843.c
    drivers/ad7843/: rt_hw_ad7843_init.c
  group ADXL345
    drivers/ADXL345/src/: adxl345.c
    drivers/ADXL345/port/: adxl345_port.c
  group agile_modbus
    packages/agile_modbus-v1.1.2/src/: agile_modbus.c agile_modbus_rtu.c agile_modbus_tcp.c
    packages/agile_modbus-v1.1.2/util/: agile_modbus_slave_util.c
  group applications
    applications/: main.c task_gpio.c task_led.c
    ./: rtconfig.h
  group Compiler
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/core/: device.c
    ../../components/drivers/hwtimer/: hwtimer.c
    ../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c soft_i2c.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/sensor/v1/: sensor.c sensor_cmd.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi-bit-ops.c spi_core.c spi_dev.c
    ../../components/drivers/touch/: touch.c
    ../../components/drivers/watchdog/: watchdog.c
  group DOIC_protocol
    applications/DOIC_protocol/: DOIC_deal_0x4101.c DOIC_map.c DOIC_protocol.c DOIC_waiting_response.c thread_DOIC.c
  group drivers
    drivers/: board.c drv_extflash.c drv_interrupt.c drv_lcd.c drv_led.c drv_pin.c drv_rtc.c drv_sdram.c drv_soft_spi.c drv_uart.c drv_watchdog.c
    drivers/linker_scripts/: link.icf
  group DTS
    applications/DTS/: dts.c Session_DTS.c thread_DTS.c transport_DTS.c
  group Fal
    ../../components/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    drivers/Fal/inc/: fal_cfg.h
    drivers/Fal/: fal_flash_eeprom_onchip_port.c fal_flash_eeprom_onrtc_port.c fal_flash_extFlash_lpc4088_port.c fal_flash_lpc4088_port.c fal_port.c
  group Filesystem
    ../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../components/dfs/dfs_v1/filesystems/tmpfs/: dfs_tmpfs.c
  group Finsh
    ../../components/finsh/: cmd.c msh.c msh_file.c msh_parse.c shell.c
  group FlashDB
    packages/FlashDB-v1.1.2/src/: fdb.c fdb_cmd.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
    drivers/FlashDB/: fdb_init.c
  group FM31XX
    drivers/FM31XX/src/: fm31XX.c
    drivers/FM31XX/port/: fm31xx_port.c
  group Kernel
    ../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group key_Ird
    drivers/key_Ird/: drv_keyIrd.c keyIrd_port.c
  group ktime
    ../../components/drivers/ktime/src/: boottime.c cputimer.c hrtimer.c
  group Libraries
    Libraries/Drivers/source/: lpc_adc.c lpc_bod.c lpc_can.c lpc_clkpwr.c lpc_crc.c lpc_dac.c lpc_eeprom.c lpc_emac.c lpc_emc.c lpc_exti.c lpc_gpdma.c lpc_gpio.c lpc_i2c.c lpc_i2s.c lpc_iap.c lpc_lcd.c lpc_mci.c lpc_mcpwm.c lpc_nvic.c lpc_pinsel.c lpc_pwm.c lpc_qei.c lpc_rtc.c lpc_ssp.c lpc_systick.c lpc_timer.c lpc_uart.c lpc_wwdt.c
    Libraries/Drivers/spifi/: spifilib_dev_common.c spifilib_fam_standard_cmd.c
    Libraries/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/IAR/: startup_LPC407x_8x_177x_8x.s
    Libraries/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
  group LVGL
    packages/LVGL-v8.3.5/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3.5/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.3.5/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    packages/LVGL-v8.3.5/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.5/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    packages/LVGL-v8.3.5/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.5/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    packages/LVGL-v8.3.5/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.5/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.5/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    packages/LVGL-v8.3.5/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    packages/LVGL-v8.3.5/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    packages/LVGL-v8.3.5/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    packages/LVGL-v8.3.5/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    packages/LVGL-v8.3.5/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    packages/LVGL-v8.3.5/src/extra/: lv_extra.c
    packages/LVGL-v8.3.5/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.5/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.5/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    packages/LVGL-v8.3.5/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v8.3.5/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.5/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    packages/LVGL-v8.3.5/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.5/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.5/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.5/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.5/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.5/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    packages/LVGL-v8.3.5/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.5/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.5/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.5/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.5/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.5/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.5/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.5/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.5/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.5/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.5/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.5/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.3.5/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.5/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.3.5/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.5/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.5/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.5/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.5/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.5/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.5/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.5/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.5/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.5/src/extra/widgets/win/: lv_win.c
  group LVGL-port
    drivers/lvgl/: lv_conf.h lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.3.5/env_support/rt-thread/: lv_rt_thread_port.c
  group LVGL-SquareLine
    applications/lvgl/fonts/: lv_font_montserratMedium_12.c lv_font_montserratMedium_16.c lv_font_simhei_12.c lv_font_simhei_14.c lv_font_simhei_16.c lv_font_simhei_20.c ui_font_heiti12.c ui_font_heiti16.c ui_font_heiti24.c
    packages/LVGL-v8.3.5/env_support/rt-thread/squareline/: lv_ui_entry.c
    applications/lvgl/: ui.c ui_helpers.c
    applications/lvgl/screens/: ui_calibration.c ui_P00startup.c ui_P00startup_event.c ui_P01main.c
    applications/lvgl/components/: ui_comp.c ui_comp_edit.c ui_comp_page_Dashboard_ctl.c ui_comp_page_Dashboard_sensor.c ui_comp_statebar.c ui_comp_tabview_main.c ui_comp_titlebar.c ui_tabview_page_about.c ui_tabview_page_Dashboard.c ui_tabview_page_debug.c ui_tabview_page_sen_config.c
    applications/lvgl/images/: ui_img_gltech_png.c ui_img_logo_png.c
  group POSIX
    ../../components/libc/posix/delay/: delay.c
  group Protocol
    applications/Protocol/: Session_master.c Transport.c
  group SDC_protocol
    applications/SDC_protocol/: SDC_deal_0x90.c SDC_map.c SDC_protocol.c SDC_waiting_response.c sensor_var.c
  group SEGGER_RTT
    packages/SEGGER_RTT-latest/adapter/: drv_rtt.c
    packages/SEGGER_RTT-latest/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group system
    applications/system/: system_var.c systemerror.c
  group Utilities
    ../../components/utilities/ulog/backend/: console_be.c
    ../../components/utilities/ulog/: ulog.c
