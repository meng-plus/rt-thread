# IAR project project.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: HC32L196xC XHSC HC32L196xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: packages\SEGGER_RTT-latest\RTT; ..\..\include; ..\..\components\drivers\include; ..\..\libcpu\arm\common; ..\..\components\libc\posix\io\poll; ..\..\components\libc\posix\ipc; drivers; .; board; ..\..\libcpu\arm\cortex-m0; ..\..\components\fal\inc; ..\..\components\libc\posix\io\eventfd; Libraries\CMSIS\Include; ..\..\components\libc\compilers\common\include; ..\..\components\drivers\spi; applications; ..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\components\finsh; ..\..\components\libc\compilers\common\extension; ..\..\components\libc\posix\io\epoll; packages\FlashDB-v1.1.2\inc; packages\rs485-latest\inc; Libraries\HC32L196_StdPeriph_Driver\inc; packages\SEGGER_RTT-latest; Libraries\CMSIS\Device\HDSC\HC32L196\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkConfigDefines: _LINK_FLASH_= 0; _HC32F448_256K_= 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  group Applications
    applications/: system_upload.c system_var.c main.c
  group Compiler
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: dac.c
    ../../components/drivers/pin/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi-bit-ops.c spi_core.c spi_dev.c
  group Drivers
    board/: board.c board_config.c drv_ad5161.c drv_dac_out.c fal_flash_hc32l19x_port.c
    drivers/: drv_dac.c drv_gpio.c drv_soft_spi.c drv_usart.c
  group Fal
    ../../components/fal/src/: fal_rtt.c fal.c fal_partition.c fal_flash.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group FlashDB
    packages/FlashDB-v1.1.2/src/: fdb_kvdb.c fdb_cmd.c fdb_tsdb.c fdb_file.c fdb_utils.c fdb.c
  group HC32_StdPeriph
    Libraries/HC32L196_StdPeriph_Driver/src/: hc32l196_dac.c hc32l196_uart.c hc32l196_flash.c hc32l196_ddl.c hc32l196_sysctrl.c hc32l196_gpio.c
    Libraries/CMSIS/Device/HDSC/HC32L196/Source/: system_hc32l19x.c interrupts_hc32l19x.c
    Libraries/CMSIS/Device/HDSC/HC32L196/Source/IAR/: startup_hc32l19x.s
  group Kernel
    ../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group rs485
    packages/rs485-latest/src/: rs485_sample_master.c rs485.c rs485_sample_slave.c rs485_test.c
  group SEGGER_RTT
    packages/SEGGER_RTT-latest/adapter/: drv_rtt.c
    packages/SEGGER_RTT-latest/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
